# IAR project Project.ewp, settings and files
configuration Discover-More (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery; ..\..\..\..\Utilities\lwip_v1.3.2\src\include\netif; ..\..\..\..\Utilities\lwip_v1.3.2\src\include\lwip; ..\..\..\..\Utilities\lwip_v1.3.2\src\include\ipv4; ..\..\..\..\Utilities\lwip_v1.3.2\src\include; ..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7\FreeRTOS; ..\..\..\..\Utilities\lwip_v1.3.2\port\STM32F4x7; ..\..\..\..\Utilities\FreeRTOS_v6.1.0\include; ..\..\..\..\Utilities\FreeRTOS_v6.1.0\portable\EWARM\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ./: startup_stm32f4xx.s
  group FreeRTOS
    ../../../../Utilities/FreeRTOS_v6.1.0/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/portable
    ../../../../Utilities/FreeRTOS_v6.1.0/portable/MemMang/: heap_2.c
    ../../../../Utilities/FreeRTOS_v6.1.0/portable/EWARM/ARM_CM3/: port.c portasm.s
  group LWIP
    ../../../../Utilities/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../Utilities/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../Utilities/lwip_v1.3.2/src/netif/: etharp.c loopif.c slipif.c
    ../../../../Utilities/lwip_v1.3.2/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group Readme
    ../: readme.txt
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lcd.c
  group STM32F4x7_ETH_Driver
    ../../../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group User
    ../src/: ATV_commands.c emb_flash_read_write.c fs.c httpserver-socket.c main.c math_func.c netconf.c plis_command.c stm32f4x7_eth_bsp.c stm32f4xx_it.c system_stm32f4xx.c
